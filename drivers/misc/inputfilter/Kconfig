## drivers/misc/inputfilter/Kconfig
```kconfig
config SWEEP2SLEEP
        tristate "Sweep to put device to sleep"
        default n
        help
          Say Y here to support sweep2sleep
```
